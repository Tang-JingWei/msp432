# Keil uVision project empty.uvprojx, settings and files
target empty (ARM-ADS)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: fromelf --bin --output .\Build\empty.bin .\Build\empty.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;.\Sys;.\Hardware\LED;.\Hardware\KEY;.\Hardware\TIM;.\Hardware\OLED;.\Hardware\UART;.\Hardware\SR04;.\Hardware\MOTOR;.\Hardware\SR04;.\Hardware\MPU6050;.\Hardware\MPU6050\eMPL;.\Hardware\SERVO;.\Hardware\GRAYSENSOR;.\Hardware\PID;.\Hardware\MATH
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group sys
    ./Sys/: interrupt.c sysinit.c delay.c baudrate_calculate.c
    ./Hardware/MATH/: bsp_math.c
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group led
    ./Hardware/LED/: led.c
  group key
    ./Hardware/KEY/: key.c
  group timer
    ./Hardware/TIM/: bsp_systick.c tim_A0.c tim_A1.c tim_A2.c tim_A3.c tim32_0.c tim32_1.c
  group oled
    ./Hardware/OLED/: oled.c
  group uart
    ./Hardware/UART/: uart_0.c uart_1.c uart_2.c uart_3.c bsp_uart.c
  group adc14
    ./Hardware/ADC14/: bsp_adc14.c
  group sr04
    ./Hardware/SR04/: sr04.c
  group motor
    ./Hardware/MOTOR/: motor.c
    ./Hardware/PID/: pid.c
  group mpu6050
    ./Hardware/MPU6050/: mpu6050.c myiic.c
    ./Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group servo
    ./Hardware/SERVO/: servo.c
  group graysensor
    ./Hardware/GRAYSENSOR/: graysensor.c
  group Doc
    ./Doc/: 资源概览.txt
software components: CMSIS:CORE 4.3.0
